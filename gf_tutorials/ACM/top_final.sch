v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {A 5-DC-parameter MOSFET model for circuit 
simulation using Open-source EDA Tools} 420 -555 0 0 0.5 0.5 { layer=8}
T {ACM2.0} 640 -445 0 0 0.5 0.5 { layer=8}
T {Thank you for your attention!} 480 -175 0 0 0.5 0.5 { layer=16}
T {SPICE Simulator: ngspice

Schematic editor: xschem

PDK (BSIM): GLOBALFOUNDRIES 180nm} 880 -425 0 0 0.4 0.4 { layer=5}
C {/home/lci-ufsc/Desktop/work_gf180/ACM/nmos_acm.sym} 580 -360 0 0 {name=N1 
model=NMOS_ACM 
w=1u 
l=1u 
n=1 
is=5u 
vt0=0.5
sigma=20m 
zeta=5m
}
C {/home/lci-ufsc/Desktop/work_gf180/ACM/pmos_acm.sym} 780 -360 0 0 {name=N2 
model=PMOS_ACM 
w=1u 
l=1u 
n=1 
is=5u 
vt0=0.5
sigma=20m 
zeta=5m
}
